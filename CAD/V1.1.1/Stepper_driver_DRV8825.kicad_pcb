# Repository test-gh-syncer2/Soldered-Stepper-motor-driver-DRV8825-board-hardware-design

## KiCad design CAD/V1.1.1/Stepper_driver_DRV8825.kicad_pcb

Parts:
C1: 12101C335K4T2A; 1210C
C2, C3, C4: CL21B104KCFNNNE; 0805C
C5: 08051C103KAT2A; 0805C
C6: 0.47uF; 0603C
D1: purple; 0402LED
FD1: FIDUCIAL; FIDUCIAL_23
H1, H2, H3, H4: HOLE_3.2mm
JP1: SMD-JUMPER-CONNECTED_TRACE_SLODERMASK
K1, K2: HEADER_MALE_8X1
R1, R3: 73L2R20G; 0603R
R2: 1M; 0603R
R4: tc33x-2-104e; tc33x-2-103e
R5: 1.5k; 0603R
R6, R8: 10k; 0603R
R7: 2k2; 0402R
U1: DRV8825

Connections:
3V3: C6.2, R4.1, U1.15 (V3P3OUT)
A1: K2.4, U1.5 (AOUT1)
A2: K2.3, U1.7 (AOUT2)
B1: K2.5, U1.10 (BOUT1)
B2: K2.6, U1.8 (BOUT2)
DECAY: U1.19 (DECAY)
DIR: K1.1, U1.20 (DIR)
GND: C1.1, C2.1, C3.1, C6.1, D1.2 (K), K2.1, K2.7, R1.1, R3.1, R4.3, U1.14 (GND), U1.28 (GND), U1.29 (TP)
MODE0: K1.7, U1.24 (MODE0)
MODE1: K1.6, U1.25 (MODE1)
MODE2: K1.5, U1.26 (MODE2)
unnamed: C4.2, R2.2, U1.3 (VCP)
unnamed: C5.1, U1.2 (CP2)
unnamed: C5.2, U1.1 (CP1)
unnamed: D1.1 (A), R7.2
unnamed: JP1.2, R7.1
unnamed: R1.2, U1.6 (ISENA)
unnamed: R3.2, U1.9 (ISENB)
unnamed: R4.2, U1.12 (AVREF), U1.13 (BVREF)
unnamed: R5.2, U1.18 (nFAULT)
STEP: K1.2, U1.22 (STEP)
VMM: C1.2, C2.2, C3.2, C4.1, JP1.1, K2.8, R2.1, U1.4 (VMA), U1.11 (VMB)
~EN: K1.8, U1.21 (nENBL)
~FAULT: K2.2, R5.1, R6.2, R8.2
~RESET: K1.4, R8.1, U1.16 (nRESET)
~SLEEP: K1.3, R6.1, U1.17 (nSLEEP)

Notes on the sheet:
DRV8825 STEPPER DRIVER
PWR LED
HEADER

Board: 2 copper layers, 22.0 x 38.0 mm, 24 parts (2 on the bottom side), 25 nets.

## Commit log

2021-09-23 Syncing to git
